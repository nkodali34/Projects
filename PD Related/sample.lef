MACRO AND2
  CLASS CORE ;
  SIZE 1.2 BY 4.8 ;
  PIN A
    DIRECTION INPUT ;
  END A
  PIN B
    DIRECTION INPUT ;
  END B
  PIN Y
    DIRECTION OUTPUT ;
  END Y
END AND2

MACRO OR2
  CLASS CORE ;
  SIZE 1.4 BY 4.8 ;
  PIN A
    DIRECTION INPUT ;
  END A
  PIN Y
    DIRECTION OUTPUT ;
  END Y
END OR2

MACRO DFF
  CLASS CORE ;
  SIZE 2.4 BY 4.8 ;
  PIN CLK
    DIRECTION INPUT ;
  END CLK
  PIN D
    DIRECTION INPUT ;
  END D
  PIN Q
    DIRECTION OUTPUT ;
  END Q
END DFF
